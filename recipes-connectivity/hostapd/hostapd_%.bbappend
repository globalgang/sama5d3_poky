#remove about run hostpad in boot on time.

INITSCRIPT_NAME = "hostapd"
INITSCRIPT_PARAMS = "remove"

inherit update-rc.d